# Keil uVision project STM32.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Lib\CMSIS;..\..\Lib\FWLIB\inc;..\..\User;..\..\User\Led;..\..\User\SysTick;..\..\User\usart;..\..\User\spi_flash;..\..\User\ff\src;..\..\User\Ethernet\W5500;..\..\User\Ethernet\Internet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Lib/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group FWLIB
    ../../Lib/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../Lib/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h
  group USER
    ../../User/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart1.c
    ../../User/spi_flash/: bsp_spi_flash.c
  group DOC
    ../../Doc/: readme.txt
  group FATFS
    ../../User/ff/src/: diskio.c ff.c
    ../../User/ff/src/option/: cc936.c
  group W5500
    ../../User/Ethernet/W5500/: md5.c socket.c utility.c w5500.c w5500_conf.c
  group Internet
    ../../User/Ethernet/Internet/: ping.c
